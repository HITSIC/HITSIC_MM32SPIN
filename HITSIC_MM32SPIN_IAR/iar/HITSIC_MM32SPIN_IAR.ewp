# IAR project HITSIC_MM32SPIN_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PS MindMotion MM32SPIN27PS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM0P1; OVERTIME=0; CLOCK=8000000; DEBUG
  ICCARM.CCDiagSuppress: pa082,pe223,pe1665
  ICCARM.CCIncludePath2: ..\board; ..\CMSIS; ..\device; ..\drivers\inc; ..\source; ..\device; ..\startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: HITSIC_MM32SPIN_IAR.srec
  ILINK.IlinkOutputFile: HITSIC_MM32SPIN_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group board
    ../board/: board.c board.h
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group device
    ../device/: mm32.h resource.c resource.h system_mm32.c system_mm32.h types.h vcdefine_v1.h
  group drivers
    ../drivers/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
    ../drivers/inc/: HAL_adc.h HAL_aes.h HAL_bkp.h HAL_can.h HAL_comp.h HAL_crc.h HAL_crs.h HAL_dac.h HAL_dbg.h HAL_div.h HAL_dma.h HAL_exti.h HAL_flash.h HAL_gpio.h HAL_i2c.h HAL_iwdg.h HAL_nvic.h HAL_opamp.h HAL_pwr.h HAL_rcc.h HAL_rtc.h HAL_spi.h HAL_sqrt.h HAL_tim.h HAL_uart.h HAL_uid.h HAL_wwdg.h
  group source
    ../source/: isr.cpp main.cpp syscalls.c
  group startup
    ../startup/: startup_mm32.c startup_mm32.h
